<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>lib</name>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\cmp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\cpuidy.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\enet.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\flexbus.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\ftm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\i2s.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\lptmr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\nfc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\pdb.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\pit.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\sd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\systick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\tsi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\vref.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\drivers\K\src\wdog.c</name>
    </file>
  </group>
  <group>
    <name>startup</name>
    <file>
      <name>$PROJ_DIR$\..\lib\startup\DeviceSupport\IAR-ARM\startup_MK60D10.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\startup\DeviceSupport\system_MK60D10.c</name>
    </file>
  </group>
  <group>
    <name>user</name>
    <group>
      <name>driver</name>
      <file>
        <name>$PROJ_DIR$\..\src\driver\ccd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\driver\driver.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\driver\motor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\driver\myclock.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\driver\myuart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\driver\speed_measuring.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\driver\steer.c</name>
      </file>
    </group>
    <group>
      <name>strategy</name>
      <file>
        <name>$PROJ_DIR$\..\src\strategy\motor_pid.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\strategy\strategy.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\strategy\target_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\strategy\UI.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\src\app.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\mycommon.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\res_ref.h</name>
    </file>
  </group>
</project>


