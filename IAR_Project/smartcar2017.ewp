# IAR project smartcar2017.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MK60D10
  ICCARM.CCIncludePath2: ..\lib\startup\CoreSupport; ..\lib\startup\DeviceSupport; ..\src; ..\lib\drivers\K\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: smartcar2017.srec
  ILINK.IlinkOutputFile: smartcar2017.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\lib\drivers\K\inc; ..\lib\startup\CoreSupport; ..\lib\startup\DeviceSupport; ..\src
  ICCARM.CCOptStrategy: 0
  group lib
    ../lib/drivers/K/src/: adc.c can.c cmp.c common.c cpuidy.c crc.c dac.c dma.c enet.c flash.c flexbus.c ftm.c gpio.c i2c.c i2s.c lptmr.c nfc.c pdb.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c vref.c wdog.c
  group startup
    ../lib/startup/DeviceSupport/IAR-ARM/: startup_MK60D10.s
    ../lib/startup/DeviceSupport/: system_MK60D10.c
  group user
    ../src/: app.c mycommon.h res_ref.h
  group user/driver
    ../src/driver/: ccd.c driver.h motor.c myclock.c myuart.c speed_measuring.c steer.c
  group user/strategy
    ../src/strategy/: motor_pid.c strategy.h target_config.c UI.c
